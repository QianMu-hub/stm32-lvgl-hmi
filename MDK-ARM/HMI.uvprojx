# Keil uVision project HMI.uvprojx, settings and files
target HMI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: HMI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../Port;../User;..\App;../Middlewares/cJSON;../Middlewares/LVGL;../Middlewares/LVGL/src;../Middlewares/LVGL/src/core;../Middlewares/LVGL/src/display;../Middlewares/LVGL/src/draw;../Middlewares/LVGL/src/drivers;../Middlewares/LVGL/src/font;../Middlewares/LVGL/src/indev;../Middlewares/LVGL/src/layouts;../Middlewares/LVGL/src/libs;../Middlewares/LVGL/src/misc;../Middlewares/LVGL/src/osal;../Middlewares/LVGL/src/others;../Middlewares/LVGL/src/stdlib;../Middlewares/LVGL/src/themes;../Middlewares/LVGL/src/tick;../Middlewares/LVGL/src/widgets
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User;..\Port;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: HMI\HMI.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User
    ../User/: user_main.c ui_ir.c city_config.c date_to_timestamp.c json_analysis.c
  group Port
    ../Port/: lv_port_disp.c lv_port_indev.c
  group BSP
    ../BSP/: driver_ir_receiver.c driver_timer.c ESP8266.c font.c GPIO_Driver.c ST7789.c UART.c user_it.c user_tim.c RTC.c
  group cJSON
    ../Middlewares/cJSON/: cJSON.c
  group LVGL/core
    ../Middlewares/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group LVGL/display
    ../Middlewares/LVGL/src/display/: lv_display.c
  group LVGL/draw
    ../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/LVGL/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/LVGL/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middlewares/LVGL/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../Middlewares/LVGL/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../Middlewares/LVGL/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../Middlewares/LVGL/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Middlewares/LVGL/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/LVGL/src/draw/opengles/: lv_draw_opengles.c
    ../Middlewares/LVGL/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Middlewares/LVGL/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/LVGL/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/LVGL/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group LVGL/font
    ../Middlewares/LVGL/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/indev
    ../Middlewares/LVGL/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL/layouts
    ../Middlewares/LVGL/src/layouts/: lv_layout.c
    ../Middlewares/LVGL/src/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/src/layouts/flex/: lv_flex.c
  group LVGL/libs
    ../Middlewares/LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/LVGL/src/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../Middlewares/LVGL/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Middlewares/LVGL/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../Middlewares/LVGL/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Middlewares/LVGL/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../Middlewares/LVGL/src/libs/gif/: lv_gif.c
    ../Middlewares/LVGL/src/libs/gif/AnimatedGIF/src/: gif.c
    ../Middlewares/LVGL/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../Middlewares/LVGL/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../Middlewares/LVGL/src/libs/gstreamer/: lv_gstreamer.c
    ../Middlewares/LVGL/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Middlewares/LVGL/src/libs/libpng/: lv_libpng.c
    ../Middlewares/LVGL/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Middlewares/LVGL/src/libs/lz4/: lz4.c
    ../Middlewares/LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/src/libs/rle/: lv_rle.c
    ../Middlewares/LVGL/src/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Middlewares/LVGL/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/LVGL/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Middlewares/LVGL/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../Middlewares/LVGL/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../Middlewares/LVGL/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
  group LVGL/misc
    ../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
  group LVGL/osal
    ../Middlewares/LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os.c lv_os_none.c
  group LVGL/others
    ../Middlewares/LVGL/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/LVGL/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/src/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/src/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/src/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/src/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/src/others/observer/: lv_observer.c
    ../Middlewares/LVGL/src/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/src/others/sysmon/: lv_sysmon.c
    ../Middlewares/LVGL/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Middlewares/LVGL/src/others/translation/: lv_translation.c
    ../Middlewares/LVGL/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Middlewares/LVGL/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../Middlewares/LVGL/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group LVGL/stdlib
    ../Middlewares/LVGL/src/stdlib/: lv_mem.c
    ../Middlewares/LVGL/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group LVGL/themes
    ../Middlewares/LVGL/src/themes/: lv_theme.c
    ../Middlewares/LVGL/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/LVGL/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/src/themes/default/: lv_theme_default.c
  group LVGL/tick
    ../Middlewares/LVGL/src/tick/: lv_tick.c
  group LVGL/widgets
    ../Middlewares/LVGL/src/widgets/win/: lv_win.c
    ../Middlewares/LVGL/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/src/widgets/scale/: lv_scale.c
    ../Middlewares/LVGL/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/LVGL/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/LVGL/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/LVGL/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/LVGL/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/LVGL/src/widgets/3dtexture/: lv_3dtexture.c
  group LVGL
    ../Middlewares/LVGL/src/: lv_init.c
    ../Middlewares/LVGL/: lv_conf.h
software components: CMSIS:CORE 4.3.0
